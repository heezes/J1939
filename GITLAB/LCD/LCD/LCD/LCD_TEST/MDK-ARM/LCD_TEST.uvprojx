# Keil uVision project LCD_TEST.uvprojx, settings and files
target LCD_TEST (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: LCD_TEST +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  ..\Drivers\BSP\Components\ili9341;  ..\Drivers\BSP\STM32F429I-Discovery;  ..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c
    ./: stlogo.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c
  group BSP/STM32F429i_Discovery
    ../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.h stm32f429i_discovery.c
  group BSP/Components
    ../Drivers/BSP/Components/ili9341/: ili9341.c ili9341.h disp.c color.h disp.h misc_conf.h
software components: CMSIS:CORE 4.1.0
