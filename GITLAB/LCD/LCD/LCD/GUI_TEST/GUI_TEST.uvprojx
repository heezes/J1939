# Keil uVision project GUI_TEST.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUI_TEST
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: .\Drivers\BSP\Components\ili9341;.\Drivers\BSP\STM32F429I-Discovery;..\GUI_TEST
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group Drivers/BSP/Components/ili9341
    ./Drivers/BSP/Components/ili9341/: disp.c ili9341.c color.h disp.h ili9341.h
  group Drivers/BSP/STM32F429I-Discovery
    ./Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h
  group misc
    ./misc/: misc.c licence.txt misc.h misc_conf_templ.h
software components: CMSIS:CORE 5.0.2, Board Support:LED 1.0.0, CMSIS Driver:SPI 2.9, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:DMA2D 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:LTDC 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:Startup 2.6.0
